# Keil uVision project main.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: main +hex
  AfterMake: fromelf.exe   --bin -o   .\main.bin  ..\output\main.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\Inc;..\Middlewares\FatFs\src;..\Middlewares\STM32_USB_Device_Library\Class\CDC\Inc;..\Middlewares\STM32_USB_Device_Library\Core\Inc;..\Middlewares\STM32_USB_Device_Library\Templates\Inc;..\Middlewares\OpenMV\inc;..\Middlewares\OpenMV\img
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Examples
    ../Src/examples/: blob_detection.c face_detection.c find_qrcodes.c line_following.c
  group Application/User
    ../Src/: main.c stm32h7xx_it.c
  group Application/App
    ../Src/: set.c ugui.c SDFatfs.c
  group Application/Device
    ../Src/: common.c ringbuffer.c xprintf.c bsp_usart.c bsp_mcu.c bsp_st7789vw.c bsp_driver_sd.c
  group Middlewares/FatFs
    ../Middlewares/FatFs/src/: diskio.c ff.c ff_gen_drv.c sd_diskio.c
    ../Middlewares/FatFs/src/option/: syscall.c
  group Middlewares/USB
    ../Middlewares/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/STM32_USB_Device_Library/Templates/Src/: usbd_conf.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/OMV
    ../Middlewares/OpenMV/src/: cambus.c mutex.c xalloc.c fb_alloc.c umm_malloc.c array.c ff_wrapper.c framebuffer.c ov7725.c ov2640.c sensor.c
  group Middlewares/IMG
    ../Middlewares/OpenMV/img/: agast.c apriltag.c binary.c blob.c bmp.c clahe.c collections.c draw.c edge.c eye.c fast.c fft.c filter.c fmath.c font.c fsort.c gif.c haar.c hog.c hough.c dmtx.c imlib.c integral.c integral_mw.c invariant_tab.c jpeg.c kmeans.c lab_tab.c lbp.c line.c lsd.c mathop.c mjpeg.c orb.c phasecorrelation.c point.c pool.c ppm.c qrcode.c qsort.c rainbow_tab.c rectangle.c rgb2rgb_tab.c selective_search.c shadow_removal.c sincos_tab.c stats.c template.c xyz_tab.c yuv_tab.c zbar.c
target Release (ARM-ADS)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: as above
  output: main
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: ROM 0x30000000 size 0x48000
  memory RVCT7: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:STM32Cube HAL:COMP 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DCMI 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:Flash 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:MMC 1.6.0, Device:STM32Cube HAL:PCD 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SD 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:STM32Cube LL:USB 1.6.0, Device:Startup 1.6.0
